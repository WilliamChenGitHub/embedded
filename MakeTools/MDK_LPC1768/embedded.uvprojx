# Keil uVision project embedded.uvprojx, settings and files
target embedded (6190000::V6.19::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: embedded (library)
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\Algorithm;..\..\Common;..\..\DataStruct;..\..\Test;..\..\Tools\Communication;..\..\Tools\JSON;..\MDK_LPC1768;..\..\Tools\ThreadPool;..\..\Tools\TCPCliSer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Algorithm
    ../../Algorithm/: Sort.c
  group Common
    ../../Common/: Log.c Miscellaneous.c MmMngr.c Thread.c
  group DataStruct
    ../../DataStruct/: Graph.c HashTable.c List.c Queue.c Stack.c Tree.c
  group Tools
    ../../Tools/Communication/: Communication.c Transfer.c TransferFactory.c
    ../../Tools/JSON/: JSON.c
